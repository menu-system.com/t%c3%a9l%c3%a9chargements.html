Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2023-11-20T14:05:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 20 14:05:22 2023 * Host: CAD-PC-05 * Database: C:\Temp\{D21EB5D3-2339-4308-ADFF-234C6C11F323}\ifc * Database version: 5507 * Database creation date: Mon Nov 20 14:05:22 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Nov 20 14:05:22 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 20 14:05:22 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 46, 54, 59, 757385; RefLongitude: 7, 27, 59, 759788; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 mm

# IfcFurnishingElement: Einbau Infrarot 2er-Kochfeld_MS-IR-20 E, MS-IR-20 E_Einbau Infrarot 2er-Kochfeld:Einbau Infrarot 2er-Kochfeld_MS-IR-20 E:361826
In: Ebene 0
Type - Material: MS_Finishes_Red, MS_Finishes_Black_shiny, MS_Finishes_Alu, MS_Finishes_Stainless_Steel, MS_Ceramic_Glass
Pset_ManufacturerTypeInformation - Manufacturer: Menu System AG; Hersteller: Menu System AG; Modell: Einbau Infrarotkochfeld mit 2 Heizzonen; Typenkommentare: MS-IR-20 E; Länge Gerätebreite: 356 mm; Tiefe: 656 mm; Höhe: 126 mm; Artikel Nummer: 123260; Gerätegewicht Netto: 28; Großküchengerätezuordnung: yes; Internetadresse für die Maßzeichnung: https://www.menu-system.com/de/hauptseiten/einzelgeraete/einzelgeraeete-produkte/einbaugeraete-infrarot.html#4362; Spannung: 400 V; Elektrische leistung: 8000 W; Stecker System: CEE 16; Maximale Geräteabsicherung: 16 A; Phasen: 3; Frequenz: 50 Hz
