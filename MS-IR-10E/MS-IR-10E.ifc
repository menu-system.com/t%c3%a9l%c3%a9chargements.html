Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2023-11-20T14:04:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 20 14:04:30 2023 * Host: CAD-PC-05 * Database: C:\Temp\{B6C8042B-4642-482A-8233-B11FB14401FE}\ifc * Database version: 5507 * Database creation date: Mon Nov 20 14:04:29 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Nov 20 14:04:29 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 20 14:04:29 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 46, 54, 59, 757385; RefLongitude: 7, 27, 59, 759788; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 mm

# IfcFurnishingElement: Einbau Infrarot 1er-Kochfeld_MS-IR-10 E, MS-IR-10 E_Einbau Infrarot 1er-Kochfeld:Einbau Infrarot 1er-Kochfeld_MS-IR-10 E:361826
In: Ebene 0
Type - Material: MS_Finishes_Red, MS_Finishes_Black_shiny, MS_Finishes_Alu, MS_Finishes_Stainless_Steel, MS_Ceramic_Glass
Pset_ManufacturerTypeInformation - Manufacturer: Menu System AG; Hersteller: Menu System AG; Modell: Einbau Infrarotkochfeld mit 1er Heizzone; Typenkommentare: MS-IR-10 E; Länge Gerätebreite: 388 mm; Tiefe: 388 mm; Höhe: 126 mm; Artikel Nummer: 123259; Gerätegewicht Netto: 14; Großküchengerätezuordnung: yes; Internetadresse für die Maßzeichnung: https://www.menu-system.com/de/hauptseiten/einzelgeraete/einzelgeraeete-produkte/einbaugeraete-infrarot.html#4361; Spannung: 400 V; Elektrische leistung: 4000 W; Stecker System: CEE 16 oder Typ 15; Maximale Geräteabsicherung: 16 A; Phasen: 3; Frequenz: 50 Hz
