Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2024-05-22T13:19:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed May 22 13:19:28 2024 * Host: CAD-PC-05 * Database: C:\Users\ISCE77~1.CAD\AppData\Local\Temp\{C7B30F88-60D9-452A-9888-5CD4DC9DEC5F}\ifc * Database version: 5507 * Database creation date: Wed May 22 13:19:27 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed May 22 13:19:27 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed May 22 13:19:27 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 46, 54, 59, 757385; RefLongitude: 7, 27, 59, 759788; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 m

# IfcFurnishingElement: Einbau-Grillplatte_MS-G-90 E, MS-G-90 E_Einbau-Grillplatte:Einbau-Grillplatte_MS-G-90 E:338617
In: Ebene 0
Type - Material: MS_Finishes_Red, MS_Finishes_Alu, MS_Finishes_Yellow, MS_Finishes_White, MS_Finishes_Black_shiny, MS_Finishes_Grün, MS_Finishes_Orange, MS_Finishes_Stainless_Steel
Pset_ManufacturerTypeInformation - Manufacturer: Menu System AG
BaseQuantities Elektro - Anschluss an Energieoptimierungsanlage: no; Anzahl der Pole: 3; Datenschnittstelle: no; Hauptschalter integriert: no; Phasen: 3; Stecker System: CEE 16 oder Typ 25; Zuleitung zum Gerät im Lieferumfang: yes
IFC-Parameter - IfcExportAs: IfcFurnishingElement
BaseQuantities Allgemein - Höhe: 0.1425 m; Logo anzeigen: yes; Länge Gerätebreite: 0.908 m; Tiefe: 0.608 m
BaseQuantities ID-Daten - Artikel Nummer: 121579; Großküchengerätezuordnung: yes; Internetadresse für die Maßzeichnung: https://www.menu-system.com/de/hauptseiten/einzelgeraete/einzelgeraeete-produkte/einzelgeraete-grillplatten-braeter.html#4368; Modell: Einbau Hartchrom Grillplatte 90*60 mit 2 Heizzonen; Hersteller: Menu System AG; Typenkommentare: MS-G-90 E; Beschreibung: Einbau Hartchrom Grillplatte 90*60
